# Repository divs16/EE201-FALL

File README.md:

# EE201-FALL
**INTRO**
 Hi, my name is Divyanshi Sharma. I am a junior at University of Washington and my major is *Electrical and computer engineering*. My hobbies are:

1. Hiking
2. Baking
3. Reading
I’m very excited to take EE 201 this fall.

## KiCad design PCB/Lab2-2023-10-16_184807/Lab2.kicad_pcb

Parts:
C1: 10 µF; CP_EIA-3216-18_Kemet-A_Pad1.58x1.35mm_HandSolder
C2: 0.01µF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D1, D2: LED; LED_1206_3216Metric_Pad1.42x1.75mm_HandSolder
J1: +9V; JST_EH_S2B-EH_1x02_P2.50mm_Horizontal
R1, R3, R4: 1k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R2: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
U1: SOIC-8-1EP_3.9x4.9mm_P1.27mm_EP2.29x3mm

Connections:
+9V: D1.2 (A), J1.2, R1.1, U1.4 (R), U1.8 (VCC)
/pin 2: C1.1, R2.2, U1.2 (TR), U1.6 (THR)
/pin 3: R3.2, R4.1, U1.3 (Q)
/pin 7: R1.2, R2.1, U1.7 (DIS)
GND: C1.2, C2.2, D2.1 (K), J1.1, U1.1 (GND)
unnamed: D1.1 (K), R3.1
unnamed: D2.2 (A), R4.2
unnamed: C2.1, U1.5 (CV)

Board: 2 copper layers, 49.1 x 33.5 mm, 10 parts (0 on the bottom side), 8 nets.

## Commit log

2023-10-02 change
2023-10-09 Added new folder to repository
2023-10-16 Commit message
2023-10-16 Add KiCad designs
2023-10-24 Added files for Lab 3 in NewDirectory_Lab3
2023-10-29 Your commit message here
2023-10-29 Add LabPrograms-arduino directory
2023-11-04 Your commit message
2023-11-04 Add Soldering_images directory and images
2023-12-05 Add images of arduometer_555 folder
